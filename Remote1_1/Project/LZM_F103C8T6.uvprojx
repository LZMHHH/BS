# Keil uVision project LZM_F103C8T6.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LZM_F103C8T6 +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\OLED_SPI;..\Top\inc;..\Basic\SYSTICK;..\Basic\LED;..\FreeRTOS\inc;..\Basic\SYS;..\Basic\DWT;..\TASK\inc;..\Basic\BSP;..\Basic\KEY;..\Basic\USART1;..\Basic\OLED;..\Zui\inc;..\Basic\ADC;..\Basic\IIC;..\Basic\EXTI;..\Basic\MPU;..\Basic\USART3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group DOC
    ../Doc/: Readme.txt
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group USER
    ../User/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h main.c
    ../FreeRTOS/inc/: FreeRTOSConfig.h
  group TOP
    ../Top/src/: control.c gather.c
    ../Basic/USART3/: protocol3.c
  group BAISE
    ../Basic/SYS/: sys.c
    ../Basic/SYSTICK/: delay.c
    ../Basic/DWT/: bsp_dwt_delay.c
    ../Basic/LED/: bsp_led.c
    ../Basic/BSP/: bsp.c
    ../Basic/KEY/: bsp_key.c
    ../Basic/USART1/: bsp_usart1.c
    ../Basic/OLED/: bsp_oled.c
    ../Basic/ADC/: bsp_adc.c
    ../Basic/EXTI/: bsp_exti.c
    ../Basic/MPU/: bsp_mpu6050.c filter.c inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../Basic/IIC/: bsp_iic.c
    ../Basic/USART3/: bsp_usart3.c
  group FreeRTOS\Ports
    ../FreeRTOS/src/: heap_4.c port.c
    ../FreeRTOS/inc/: portmacro.h
  group FreeRTOS\Source
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group TASK
    ../TASK/src/: LedTask.c KeyTask.c DisplayTask.c JoystickTask.c MpuTask.c CommunicateATask.c CommunicateCTask.c
  group ZUI
    ../Zui/src/: main_ui.c car_ui.c envi_ui.c bmp.c
