# Keil uVision project LZM_F103RCT6.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LZM_F103C8T6 +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\OLED_SPI;..\Top\inc;..\Basic\SYSTICK;..\Basic\LED;..\FreeRTOS\inc;..\Basic\SYS;..\Basic\DWT;..\Basic\BSP;..\Basic\CONFIG;..\Basic\KEY;..\TASK\inc;..\Basic\USART1;..\Basic\SDIO;..\FATFS\src;..\FATFS\src\option;..\Basic\USMART;..\Zui\inc;..\Basic\OLED;..\Basic\SHT3X;..\Basic\COLOCK;..\Basic\GY;..\Basic\USART2;..\Basic\BME;..\Basic\CAN;..\Basic\ADC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group DOC
    ../Doc/: Readme.txt
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ../User/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h main.c SysInfoTest.c
    ../FreeRTOS/inc/: FreeRTOSConfig.h
  group TOP
    ../Top/src/: control.c gather.c file_sys.c cancommunicate.c protocol.c
  group BAISE
    ../Basic/SYS/: sys.c
    ../Basic/DWT/: bsp_dwt_delay.c
    ../Basic/BSP/: bsp.c bsp_tim_pwm.c
    ../Basic/KEY/: bsp_key.c
    ../Basic/LED/: bsp_led.c
    ../Basic/SDIO/: bsp_sdio_sdcard.c
    ../Basic/SYSTICK/: delay.c
    ../Basic/USART1/: bsp_usart1.c
    ../Basic/OLED/: bsp_oled.c
    ../Basic/SHT3X/: bsp_sht3x.c
    ../Basic/COLOCK/: bsp_ds3231.c
    ../Basic/GY/: bsp_gy30.c
    ../Basic/USART2/: bsp_usart2.c
    ../Basic/BME/: bsp_bme280.c
    ../Basic/CAN/: bsp_can.c
    ../Basic/ADC/: bsp_adc.c
  group FreeRTOS\Ports
    ../FreeRTOS/src/: heap_4.c port.c
    ../FreeRTOS/inc/: portmacro.h
  group FreeRTOS\Source
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group TASK
    ../TASK/src/: KeyTask.c LedTask.c CommunicateTask.c CpuTask.c FileTask.c CheckTask.c InitTask.c DisplayTask.c EnvironmentTask.c ClockTask.c LightTask.c PmsTask.c BmeTask.c canCommunicateTask.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
  group ZUI
    ../Zui/src/: main_ui.c bmp.c car_ui.c
